Commit message: Fix the robot rotation problem

File: src/ur_e_description/urdf/ur5e.urdf (robot description, URDF)
Before this commit: robot ur5e, 39 links, 38 joints
Joints:
- joint base_link-base_fixed_joint: origin xyz=0 0 0 rpy=0 0 -3.14159265359 -> xyz=0 0 0 rpy=0 0 0
